# IAR project Backup of project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S208MB; USE_STM8_128_EVAL
  ICCSTM8.CCIncludePath2: Libraries\STM8S_StdPeriph_Driver\inc; HAL; src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.s19
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: main.c stm8s_it.c
  group HAL
    HAL/: HAL_I2C_TSL2561.c Modbus.c
  group STM8S_Periph
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
