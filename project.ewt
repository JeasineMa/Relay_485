<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>HAL</name>
    <file>
      <name>$PROJ_DIR$\HAL\HAL_I2C_TSL2561.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HAL\Modbus.c</name>
    </file>
  </group>
  <group>
    <name>STM8S_Periph</name>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\src\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\src\stm8s_it.c</name>
  </file>
</project>


